options:
  parameters:
    author: Barrios-Tirado
    copyright: uis
    generate_options: qt_gui
    id: sistemapython
    output_language: python
    title: sistema
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '220500'
  states: {}
- name: Modulos_J1A_ParteEntera_0
  id: Modulos_J1A_ParteEntera
  parameters:
    PARAM1: 'True'
    PARAM2: '200500'
  states: {}
- name: Modulos_J1A_ParteEntera_1
  id: Modulos_J1A_ParteEntera
  parameters:
    PARAM1: 'True'
    PARAM2: '220500'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulos_J1A_ParteEntera_0, '0', qtgui_time_sink_x_0, '0']
- [Modulos_J1A_ParteEntera_1, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', Modulos_J1A_ParteEntera_0, '0']
- [analog_sig_source_x_0, '0', Modulos_J1A_ParteEntera_1, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
